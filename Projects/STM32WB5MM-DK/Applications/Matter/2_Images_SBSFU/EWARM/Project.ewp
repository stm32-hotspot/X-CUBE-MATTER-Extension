# IAR project Project.ewp, settings and files
configuration STM32WB5MM_DISCO_2_Images_SBSFU (ARM, debug)
  General.OGChipSelectEditMenu: STM32WB5MMG ST STM32WB5MMG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32WB5Mxx; CKS_ENABLED; SFU_VERBOSE_DEBUG_MODE
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32WBxx_HAL_Driver/Inc; ../../../../../../Drivers/STM32WBxx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32WBxx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32WB5MM-DK; ..\Core\Inc; ..\SBSFU\App; ..\SBSFU\Target; ..\..\2_Images_SECoreBin\Inc; ..\..\Linker_Common\EWARM; ..\..\..\..\..\..\Middlewares\ST\STM32_Secure_Engine\Core; ..\..\..\..\..\..\Middlewares\ST\STM32_Secure_Engine\Interface
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  postbuild: $TOOLKIT_DIR$\bin\isymexport.exe --edit "steering_file.txt" "$TARGET_PATH$" "$PROJ_DIR$.\se_interface_appli.o"
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkKeepSymbols: SE_CORE_Bin
  ILINK.IlinkIcfFile: stm32wb5mxx_flash_cm4.icf
  ILINK.IlinkExtraOptions: --config_search ..\..\Linker_Common\EWARM\; --image_input ../../2_Images_Loader/EWARM/Loader.bin,LOADER_Bin,LOADER_Bin,1; --keep LOADER_Bin
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/Core
    ../Core/Src/: main.c stm32wbxx_hal_msp.c stm32wbxx_it.c
  group Application/EWARM
    ./: startup_stm32wb5mxx_cm4.s
  group Application/SBSFU/App
    ../SBSFU/App/: sfu_boot.c sfu_com_loader.c sfu_com_trace.c sfu_error.c sfu_fwimg_common.c sfu_fwimg_no_swap.c sfu_fwimg_swap.c sfu_loader.c sfu_new_image.c sfu_test.c
  group Application/SBSFU/Target
    ../SBSFU/Target/: sfu_low_level.c sfu_low_level_flash.c sfu_low_level_flash_ext.c sfu_low_level_flash_int.c sfu_low_level_security.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/s25fl128s/: s25fl128s.c
  group Drivers/BSP/STM32WB5MM-DK
    ../../../../../../Drivers/BSP/STM32WB5MM-DK/: stm32wb5mm_dk.c stm32wb5mm_dk_qspi.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32WBxx/Source/Templates/: system_stm32wbxx.c
  group Drivers/STM32WBxx_HAL_Driver
    ../../../../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal.c stm32wbxx_hal_adc.c stm32wbxx_hal_adc_ex.c stm32wbxx_hal_cortex.c stm32wbxx_hal_crc.c stm32wbxx_hal_crc_ex.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_exti.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_i2c.c stm32wbxx_hal_i2c_ex.c stm32wbxx_hal_iwdg.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_qspi.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_rtc.c stm32wbxx_hal_rtc_ex.c stm32wbxx_hal_spi.c stm32wbxx_hal_spi_ex.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c
  group Middlewares/STM32_Secure_Engine
    ../../../../../../Middlewares/ST/STM32_Secure_Engine/Core/: se_interface_application.c se_interface_bootloader.c se_interface_common.c
